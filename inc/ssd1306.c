#include "ssd1306.h"
#include <string.h>

static const uint8_t font5x7[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, // Espaco
    0x00, 0x00, 0x5F, 0x00, 0x00, // !
    0x00, 0x07, 0x00, 0x07, 0x00, // "
    0x14, 0x7F, 0x14, 0x7F, 0x14, // #
    0x24, 0x2A, 0x7F, 0x2A, 0x12, // $
    0x23, 0x13, 0x08, 0x64, 0x62, // %
    0x36, 0x49, 0x56, 0x20, 0x50, // &
    0x00, 0x05, 0x03, 0x00, 0x00, // '
    0x00, 0x1C, 0x22, 0x41, 0x00, // (
    0x00, 0x41, 0x22, 0x1C, 0x00, // )
    0x14, 0x08, 0x3E, 0x08, 0x14, // *
    0x08, 0x08, 0x3E, 0x08, 0x08, // +
    0x00, 0x50, 0x30, 0x00, 0x00, // ,
    0x08, 0x08, 0x08, 0x08, 0x08, // -
    0x00, 0x60, 0x60, 0x00, 0x00, // .
    0x20, 0x10, 0x08, 0x04, 0x02, // /
    0x3E, 0x51, 0x49, 0x45, 0x3E, // 0
    0x00, 0x42, 0x7F, 0x40, 0x00, // 1
    0x42, 0x61, 0x51, 0x49, 0x46, // 2
    0x21, 0x41, 0x45, 0x4B, 0x31, // 3
    0x18, 0x14, 0x12, 0x7F, 0x10, // 4
    0x27, 0x45, 0x45, 0x45, 0x39, // 5
    0x3C, 0x4A, 0x49, 0x49, 0x30, // 6
    0x01, 0x71, 0x09, 0x05, 0x03, // 7
    0x36, 0x49, 0x49, 0x49, 0x36, // 8
    0x06, 0x49, 0x49, 0x29, 0x1E, // 9
    0x00, 0x36, 0x36, 0x00, 0x00, // :
    0x00, 0x56, 0x36, 0x00, 0x00, // ;
    0x08, 0x14, 0x22, 0x41, 0x00, // <
    0x14, 0x14, 0x14, 0x14, 0x14, // =
    0x00, 0x41, 0x22, 0x14, 0x08, // >
    0x02, 0x01, 0x51, 0x09, 0x06, // ?
    0x32, 0x49, 0x79, 0x41, 0x3E, // @
    0x7E, 0x11, 0x11, 0x11, 0x7E, // A
    0x7F, 0x49, 0x49, 0x49, 0x36, // B
    0x3E, 0x41, 0x41, 0x41, 0x22, // C
    0x7F, 0x41, 0x41, 0x22, 0x1C, // D
    0x7F, 0x49, 0x49, 0x49, 0x41, // E
    0x7F, 0x09, 0x09, 0x09, 0x01, // F
    0x3E, 0x41, 0x49, 0x49, 0x7A, // G
    0x7F, 0x08, 0x08, 0x08, 0x7F, // H
    0x00, 0x41, 0x7F, 0x41, 0x00, // I
    0x20, 0x40, 0x41, 0x3F, 0x01, // J
    0x7F, 0x08, 0x14, 0x22, 0x41, // K
    0x7F, 0x40, 0x40, 0x40, 0x40, // L
    0x7F, 0x02, 0x0C, 0x02, 0x7F, // M
    0x7F, 0x04, 0x08, 0x10, 0x7F, // N
    0x3E, 0x41, 0x41, 0x41, 0x3E, // O
    0x7F, 0x09, 0x09, 0x09, 0x06, // P
    0x3E, 0x41, 0x51, 0x21, 0x5E, // Q
    0x7F, 0x09, 0x19, 0x29, 0x46, // R
    0x46, 0x49, 0x49, 0x49, 0x31, // S
    0x01, 0x01, 0x7F, 0x01, 0x01, // T
    0x3F, 0x40, 0x40, 0x40, 0x3F, // U
    0x1F, 0x20, 0x40, 0x20, 0x1F, // V
    0x3F, 0x40, 0x38, 0x40, 0x3F, // W
    0x63, 0x14, 0x08, 0x14, 0x63, // X
    0x07, 0x08, 0x70, 0x08, 0x07, // Y
    0x61, 0x51, 0x49, 0x45, 0x43  // Z
};

static void write_cmd(ssd1306_t *ssd, uint8_t cmd) {
    uint8_t buf[2] = {0x00, cmd};
    i2c_write_blocking(ssd->i2c, ssd->address, buf, 2, false);
}

void ssd1306_init(ssd1306_t *ssd, uint8_t width, uint8_t height, uint8_t address, i2c_inst_t *i2c) {
    ssd->width = width;
    ssd->height = height;
    ssd->pages = height / 8;
    ssd->address = address;
    ssd->i2c = i2c;

    uint8_t cmds[] = {
        0xAE,        // Display OFF
        0xD5, 0x80,  // Set display clock
        0xA8, height - 1, // Set multiplex ratio
        0xD3, 0x00,  // Display offset = 0
        0x40,        // Start line = 0
        0x8D, 0x14,  // Enable charge pump
        0x20, 0x00,  // Memory addressing mode: Horizontal
        0xA1,        // Segment remap
        0xC8,        // COM scan direction
        0xDA, 0x12,  // COM pins hardware configuration para 128x64
        0x81, 0xCF,  // Set contrast
        0xD9, 0xF1,  // Pre-charge period
        0xDB, 0x40,  // VCOMH deselect level
        0xA4,        // Output follows RAM
        0xA6,        // Normal display
        0xAF         // Display ON
    };

    for (size_t i = 0; i < sizeof(cmds); i++) {
        write_cmd(ssd, cmds[i]);
    }
    ssd1306_fill(ssd, false);
    ssd1306_send_data(ssd);
}

void ssd1306_fill(ssd1306_t *ssd, bool value) {
    memset(ssd->buffer, value ? 0xFF : 0x00, sizeof(ssd->buffer));
}

void ssd1306_draw_pixel(ssd1306_t *ssd, uint8_t x, uint8_t y, bool value) {
    if (x >= ssd->width || y >= ssd->height) return;
    uint16_t index = x + (y / 8) * ssd->width;
    if (value)
        ssd->buffer[index] |= (1 << (y % 8));
    else
        ssd->buffer[index] &= ~(1 << (y % 8));
}

void ssd1306_send_data(ssd1306_t *ssd) {
    for (uint8_t page = 0; page < ssd->pages; page++) {
        write_cmd(ssd, 0xB0 + page);
        write_cmd(ssd, 0x00);
        write_cmd(ssd, 0x10);

        uint8_t temp[SSD1306_WIDTH + 1];
        temp[0] = 0x40;
        memcpy(&temp[1], &ssd->buffer[page * ssd->width], ssd->width);
        i2c_write_blocking(ssd->i2c, ssd->address, temp, ssd->width + 1, false);
    }
}

void ssd1306_draw_string(ssd1306_t *ssd, uint8_t x, uint8_t y, const char *str) {
    while (*str) {
        char c = *str;
        if (c >= ' ' && c <= 'Z') {
            int idx = (c - ' ') * 5;
            for (int col = 0; col < 5; col++) {
                uint8_t line = font5x7[idx + col];
                for (int bit = 0; bit < 8; bit++) {
                    ssd1306_draw_pixel(ssd, x + col, y + bit, (line >> bit) & 0x01);
                }
            }
        }
        x += 6;
        str++;
    }
}
